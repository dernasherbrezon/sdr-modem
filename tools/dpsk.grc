options:
  parameters:
    author: dernasherbrezon
    description: Debug flowgraph for investigating a suspected DPSK signal. Lets you slide the frequency-xlating center frequency, filter cutoff/transition and decimation while watching the raw and post-xlating spectra update live, then carries the signal through Costas carrier recovery, symbol timing recovery and differential demodulation down to decoded bits.
    generate_options: qt_gui
    id: dpsk
    output_language: python
    title: DPSK investigation
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: 'TUNE THIS: shifts the signal of interest to baseband before the low-pass filter/decimation.'
    gui_hint: 0,0,1,1
    label: Center frequency (Hz)
    start: '-samp_rate / 2'
    step: '100'
    stop: samp_rate / 2
    value: '18500'
  states: {}
- name: clock_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: Symbol timing (clock recovery) loop bandwidth. Lower = smoother but slower timing tracking.
    gui_hint: 7,0,1,1
    label: Clock recovery loop bandwidth
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.003'
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: Costas loop bandwidth (rad/sample) tracking residual carrier phase/frequency after xlating. Lower = slower but less noisy phase tracking. Watch the debug constellation to judge lock.
    gui_hint: 4,0,1,1
    label: Costas loop bandwidth
    start: '0.001'
    step: '0.001'
    stop: '0.5'
    value: '0.003'
  states: {}
- name: costas_loop_bw_2
  id: variable_qtgui_range
  parameters:
    comment: Bandwidth of the second Costas loop, applied after symbol timing recovery (one sample/symbol). Cleans up residual carrier phase/frequency the first loop didn't fully track before differential decoding.
    gui_hint: 8,0,1,1
    label: Costas loop 2 bandwidth
    start: '0.001'
    step: '0.001'
    stop: '0.5'
    value: '0.003'
  states: {}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    comment: Low-pass cutoff (Hz) applied after xlating, before decimation.
    gui_hint: 1,0,1,1
    label: Cutoff frequency (Hz)
    start: '1000'
    step: '1000'
    stop: samp_rate / 4
    value: '3000'
  states: {}
- name: decim
  id: variable_qtgui_range
  parameters:
    comment: Decimation applied by the xlating filter.
    gui_hint: 3,0,1,1
    label: Decimation
    rangeType: int
    start: '1'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: rolloff
  id: variable_qtgui_range
  parameters:
    comment: RRC roll-off / excess bandwidth (alpha) for the optional matched filter stage. Only meaningful once Symbol rate is confirmed correct; common transmitter values are 0.35 or 0.5.
    gui_hint: 5,0,1,1
    label: RRC roll-off (alpha)
    start: '0.1'
    step: '0.01'
    stop: '1.0'
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate of the input file. Must match the capture.
    value: '96000'
  states: {}
- name: symbol_rate
  id: variable_qtgui_range
  parameters:
    comment: 'TUNE THIS: expected symbol/baud rate (Hz) of the DPSK signal. Feeds the symbol-sync samples-per-symbol calculation.'
    gui_hint: 6,0,1,1
    label: Symbol rate (baud)
    start: '100'
    step: '100'
    stop: samp_rate / decim / 2
    value: '1200'
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    comment: Low-pass transition width (Hz) for the xlating filter taps.
    gui_hint: 2,0,1,1
    label: Transition width (Hz)
    start: '2000'
    step: '500'
    stop: '10000'
    value: '5000'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cutoff_freq
    gain: '1.0'
    samp_rate: samp_rate
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: rolloff
    comment: RRC matched-filter taps. Only valid once Symbol rate matches the actual baud rate - wrong symbol_rate here distorts the passband instead of matching it.
    gain: '1.0'
    ntaps: int(11 * samp_rate / decim / symbol_rate)
    samp_rate: samp_rate / decim
    sym_rate: symbol_rate
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: Normalizes amplitude before the Costas loop so its error detector behaves consistently.
    gain: '1.0'
    max_gain: '65536'
    rate: 2e-2 / 80
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Point this at your .cf32 capture (complex float32 I/Q).
    file: /Users/dernasherbrezon/Downloads/satellites_backup/funcube-3/output.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: Decoded DPSK bits. Replace with a file sink to capture them.
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * decim
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Slices the differentially-decoded symbol back to a bit using a BPSK constellation.
    constellation: digital.constellation_bpsk().base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Second-order Costas loop tracks residual carrier phase/frequency after xlating (order 2 is correct for DPSK, since it is differentially-encoded BPSK).
    order: '2'
    w: costas_loop_bw
  states: {}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    comment: Second Costas loop, applied after symbol timing recovery once there is one sample per symbol. Cleans up residual carrier phase/frequency the first loop didn't fully track before differential decoding.
    order: '2'
    w: costas_loop_bw_2
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters:
    comment: Differential demodulation - multiplies each symbol by the conjugate of the previous one, which removes any residual/ambiguous absolute phase left by the Costas loop.
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Clock recovery - resamples the Costas-corrected stream down to one complex sample per symbol.
    damping: '1.0'
    loop_bw: clock_loop_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: samp_rate / decim / symbol_rate
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Optional RRC matched filter - complements (does not replace) the low-pass in the xlating filter above, which only isolates the channel. Only helps once Symbol rate/roll-off are confirmed and the transmitter is known to use RRC pulse shaping; with a wrong Symbol rate it just adds mild extra shaping rather than breaking anything. To turn it off, right-click and Bypass here - but then leave the RRC roll-off slider alone, since moving it while bypassed hits a GRC codegen bug (this block is skipped from instantiation but the roll-off slider callback still calls into it, throwing AttributeError).
    decim: decim
    taps: variable_rrc_filter_taps_0
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_freq
    comment: Shifts center_freq to baseband, low-pass filters and decimates.
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Debug view of the Costas loop output. When locked on DPSK/BPSK, points should cluster into 2 tight groups on a line through the origin instead of spreading around a circle.
    grid: 'True'
    gui_hint: 4,1,2,1
    name: '"Costas loop constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: Debug view of the Costas loop output. When locked on DPSK/BPSK, points should cluster into 2 tight groups on a line through the origin instead of spreading around a circle.
    grid: 'True'
    gui_hint: 8,1,1,1
    name: '"Costas loop 2 constellation"'
    size: '512'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,1,4,1
    name: '"Stage 1: after frequency xlating"'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_null_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_1, '0', digital_diff_phasor_cc_0, '0']
- [digital_costas_loop_cc_1, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_1, '0']
- [fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
