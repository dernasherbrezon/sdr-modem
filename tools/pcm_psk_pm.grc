options:
  parameters:
    author: dernasherbrezon
    description: Debug flowgraph for investigating a suspected PCM/PSK/PM signal (PCM data phase-shift-keyed onto a sine subcarrier, which in turn phase-modulates a residual RF carrier - the classic deep-space/telemetry format). Stage 1 tunes an xlating filter over the carrier, keeping BOTH the residual carrier and the subcarrier sidebands in the passband. A PLL locks onto the residual carrier; its output's in-phase component is the recovered carrier tone and its quadrature component carries the subcarrier phase modulation. Stage 2 xlates that subcarrier down to baseband, and the rest of the chain (matched filter, Costas loop, symbol sync, second Costas loop, differential decode) demodulates it exactly like a suppressed-carrier BPSK signal.
    generate_options: qt_gui
    id: pcm_psk_pm
    output_language: python
    title: PCM/PSK/PM investigation
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: 'TUNE THIS: shifts the residual carrier to baseband before the low-pass filter. The passband (cutoff_freq) must stay wide enough to also keep both subcarrier sidebands, not just the carrier line itself.'
    gui_hint: 1,0,1,1
    label: Center frequency (Hz)
    start: '-samp_rate / 2'
    step: '100'
    stop: samp_rate / 2
    value: '210000'
  states: {}
- name: clock_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: Symbol timing (clock recovery) loop bandwidth. Lower = smoother but slower timing tracking.
    gui_hint: 12,0,1,1
    label: Clock recovery loop bandwidth
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.005'
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: Costas loop bandwidth (rad/sample) tracking residual phase/frequency error on the subcarrier (order 2, since the subcarrier itself is suppressed-carrier BPSK). Watch the Costas loop 1 constellation to judge lock.
    gui_hint: 9,0,1,1
    label: Costas loop bandwidth
    start: '0.001'
    step: '0.001'
    stop: '0.5'
    value: '0.005'
  states: {state: disabled}
- name: costas_loop_bw_2
  id: variable_qtgui_range
  parameters:
    comment: Bandwidth of the second Costas loop, applied after symbol timing recovery (one sample/symbol). Cleans up residual phase/frequency error the first loop didn't fully track before differential decoding.
    gui_hint: 13,0,1,1
    label: Costas loop 2 bandwidth
    start: '0.001'
    step: '0.001'
    stop: '0.5'
    value: '0.005'
  states: {}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    comment: Low-pass cutoff (Hz) applied after xlating, before the PLL. Must be wider than subcarrier_freq plus its sidebands or you will filter out the data before it ever reaches the PLL.
    gui_hint: 1,1,1,1
    label: RF cutoff frequency (Hz)
    start: '1000'
    step: '1000'
    stop: samp_rate / 2
    value: '5000'
  states: {}
- name: decim
  id: variable_qtgui_range
  parameters:
    comment: Final decimation, applied by the matched-filter/decimator after subcarrier xlating (mirrors dpsk.grc - the xlating filters themselves never decimate).
    gui_hint: 1,3,1,1
    label: Decimation
    rangeType: int
    start: '1'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: decim2
  id: variable_qtgui_range
  parameters:
    comment: Final decimation, applied by the matched-filter/decimator after subcarrier xlating (mirrors dpsk.grc - the xlating filters themselves never decimate).
    gui_hint: 3,3,1,1
    label: Decimation
    rangeType: int
    start: '1'
    step: '1'
    stop: '200'
    value: '20'
  states: {}
- name: pll_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: PLL loop bandwidth (Hz) tracking the residual carrier. Lower = slower but cleaner lock; needs to be narrow enough to ignore the subcarrier's phase swings (that's what makes them show up in the Q monitor instead of being tracked out).
    gui_hint: 4,0,1,1
    label: PLL loop bandwidth (Hz)
    start: '0.1'
    step: '0.1'
    stop: '200'
    value: '5'
  states: {}
- name: rolloff
  id: variable_qtgui_range
  parameters:
    comment: RRC roll-off / excess bandwidth (alpha) for the optional matched filter stage. Only meaningful once Symbol rate is confirmed correct.
    gui_hint: 10,0,1,1
    label: RRC roll-off (alpha)
    start: '0.1'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate of the input file. Must match the capture.
    value: 1e6
  states: {}
- name: subcarrier_cutoff_freq
  id: variable_qtgui_range
  parameters:
    comment: Low-pass cutoff (Hz) isolating the subcarrier after downconversion. Should be a bit wider than symbol_rate * (1 + rolloff)/2 - too narrow clips the BPSK sidebands, too wide lets in the other sideband/harmonics.
    gui_hint: 3,1,1,1
    label: Subcarrier cutoff frequency (Hz)
    start: '100'
    step: '50'
    stop: subcarrier_freq / 2
    value: '100'
  states: {}
- name: subcarrier_freq
  id: variable_qtgui_range
  parameters:
    comment: 'TUNE THIS: expected subcarrier frequency (Hz), read off the Stage 1 spectrum as the offset of the sideband peaks either side of the locked carrier line. Common values are in the low kHz (e.g. 1-65 kHz depending on the standard).'
    gui_hint: 3,0,1,1
    label: Subcarrier frequency (Hz)
    start: '100'
    step: '100'
    stop: samp_rate / 2
    value: '2048'
  states: {}
- name: subcarrier_transition_width
  id: variable_qtgui_range
  parameters:
    comment: Low-pass transition width (Hz) for the subcarrier xlating filter taps.
    gui_hint: 3,2,1,1
    label: Subcarrier transition width (Hz)
    start: '50'
    step: '50'
    stop: '5000'
    value: '100'
  states: {}
- name: symbol_rate
  id: variable_qtgui_range
  parameters:
    comment: 'TUNE THIS: expected PCM bit/baud rate on the subcarrier. Feeds the symbol-sync samples-per-symbol calculation. Should be well below subcarrier_freq (the subcarrier is the "carrier" the PCM data phase-modulates).'
    gui_hint: 11,0,1,1
    label: Symbol rate (baud)
    start: '50'
    step: '10'
    stop: '20000'
    value: '64'
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    comment: Low-pass transition width (Hz) for the RF xlating filter taps.
    gui_hint: 1,2,1,1
    label: RF transition width (Hz)
    start: '500'
    step: '500'
    stop: '10000'
    value: '2000'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    comment: RF low-pass taps - must pass the carrier AND both subcarrier sidebands.
    cutoff_freq: cutoff_freq
    gain: '1.0'
    samp_rate: samp_rate
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: variable_low_pass_filter_taps_1
  id: variable_low_pass_filter_taps
  parameters:
    comment: Subcarrier low-pass taps, applied after downconverting the subcarrier to baseband.
    cutoff_freq: subcarrier_cutoff_freq
    gain: '1.0'
    samp_rate: samp_rate / decim
    width: subcarrier_transition_width
    win: window.WIN_HAMMING
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: rolloff
    comment: RRC matched-filter taps for the subcarrier's BPSK symbols. Only valid once Symbol rate matches the actual baud rate.
    gain: '1.0'
    ntaps: int(11 * samp_rate / decim / symbol_rate)
    samp_rate: samp_rate
    sym_rate: symbol_rate
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: Normalizes amplitude before the PLL so its phase detector behaves consistently.
    gain: '1.0'
    max_gain: '65536'
    rate: 2e-2 / 80
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    comment: Normalizes amplitude before the Costas loop so its error detector behaves consistently.
    gain: '1.0'
    max_gain: '65536'
    rate: 2e-2 / 80
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    comment: 'Locks onto the residual carrier. Internally outputs input * conj(recovered carrier tone): once locked, the real (I) part is the recovered carrier and the imaginary (Q) part carries the subcarrier''s phase modulation (that''s the data) - see the PLL I/Q monitor scope.'
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_loop_bw * decim / samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Point this at your .cf32 capture (complex float32 I/Q).
    file: /Users/dernasherbrezon/Downloads/slim_2024-01-19_15_39_58_437.200MHz_1.00Msps_ci16_le.chan0.sigmf-data
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /Users/dernasherbrezon/Downloads/slim_2024-01-19_15_39_58_437.200MHz_1.00Msps_ci16_le.chan0.sigmf-data
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: Decoded PCM bits. Replace with a file sink to capture them.
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Slices the differentially-decoded symbol back to a bit using a BPSK constellation.
    constellation: digital.constellation_bpsk().base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Second-order Costas loop tracks residual phase/frequency error on the subcarrier's BPSK modulation.
    order: '2'
    w: costas_loop_bw
  states: {state: disabled}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    comment: Second Costas loop, applied after symbol timing recovery once there is one sample per symbol. Cleans up residual phase/frequency error the first loop didn't fully track before differential decoding.
    order: '2'
    w: costas_loop_bw_2
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters:
    comment: Differential demodulation - multiplies each symbol by the conjugate of the previous one, removing any residual/ambiguous absolute phase left by the Costas loops. Only needed if the PCM data is differentially encoded (e.g. NRZ-M) - if bits come out garbled, try removing this and slicing directly.
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Clock recovery - resamples the Costas-corrected subcarrier stream down to one complex sample per symbol.
    damping: '1.0'
    loop_bw: clock_loop_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: samp_rate / decim / symbol_rate / decim2
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Optional RRC matched filter and decimator - complements (does not replace) the low-pass in the subcarrier xlating filter above. To turn off matching (keep only the decimation), right-click and Bypass here - but then leave the RRC roll-off slider alone (moving it while bypassed hits a GRC codegen bug).
    decim: '1'
    taps: variable_rrc_filter_taps_0
    type: ccf
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_freq
    comment: 'Stage 1: shifts center_freq to baseband and low-pass filters. Does not decimate (like dpsk.grc, decimation happens later at the matched-filter stage) - keep the carrier and both subcarrier sidebands in the passband.'
    decim: decim
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subcarrier_freq
    comment: 'Stage 2: shifts the subcarrier to baseband and low-pass filters it, converting the real Q stream from the PLL into a complex BPSK-like signal. Does not decimate - decimation happens at the matched-filter stage below.'
    decim: decim2
    samp_rate: samp_rate / decim
    taps: variable_low_pass_filter_taps_1
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    comment: Needed for np.pi in the PLL loop bandwidth/range expressions below.
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Debug view of the Costas loop output. When locked, points should cluster into 2 tight groups on a line through the origin instead of spreading around a circle.
    grid: 'True'
    gui_hint: 9,1,2,1
    name: '"Costas loop 1 constellation (subcarrier)"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    comment: Debug view of the second Costas loop's output, one sample per symbol.
    grid: 'True'
    gui_hint: 11,1,3,1
    name: '"Costas loop 2 constellation"'
    size: '512'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate / decim
    comment: Look for a strong carrier line plus a pair of sideband peaks +/- subcarrier_freq away - use their spacing to set subcarrier_freq. Use this to tune center_freq/cutoff_freq/transition_width.
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,1,4
    name: '"Stage 1: after RF xlating (carrier + subcarrier sidebands)"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / decim / decim2
    comment: BPSK sidebands of the subcarrier, now centered at 0 Hz. Use this to tune subcarrier_freq/subcarrier_cutoff_freq/subcarrier_transition_width.
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 2,0,1,4
    name: '"Stage 2: after subcarrier xlating"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / decim / decim2
    comment: BPSK sidebands of the subcarrier, now centered at 0 Hz. Use this to tune subcarrier_freq/subcarrier_cutoff_freq/subcarrier_transition_width.
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 9,1,2,1
    name: '"Test baud rate"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: When the PLL is locked, I should settle to a slowly-varying near-constant level (the residual carrier) while Q oscillates with the subcarrier's phase modulation. If both channels look like noisy circles/no structure, the PLL isn't locked - widen pll_freq_range or re-check center_freq.
    grid: 'True'
    gui_hint: 4,1,2,1
    label1: I (recovered carrier)
    label2: Q (subcarrier modulation)
    name: '"PLL I/Q monitor"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_agc_xx_1, '0', digital_costas_loop_cc_0, '0']
- [analog_agc_xx_1, '0', digital_symbol_sync_xx_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_null_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_1, '0', digital_diff_phasor_cc_0, '0']
- [digital_costas_loop_cc_1, '0', qtgui_const_sink_x_1, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_1, '0']
- [fir_filter_xxx_0, '0', analog_agc_xx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_agc_xx_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_delay_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_multiply_xx_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
